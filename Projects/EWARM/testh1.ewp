# IAR project testh1.ewp, settings and files
configuration testh1 Configuration (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: D:\STM32\pcb20\Inc; D:\STM32\pcb20\Drivers\CMSIS\Device\ST\STM32F4xx\Include; D:\STM32\pcb20\Drivers\STM32F4xx_HAL_Driver\Inc; D:\STM32\pcb20\Drivers\CMSIS\Include; D:\STM32\pcb20\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc; D:\STM32\pcb20\Middlewares\ST\STM32_USB_Device_Library\Core\Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: testh1.hex
  ILINK.IlinkOutputFile: testh1.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f407xx.s
  group Application/User
    ../../Src/: AD7193.h font.c main.c pcb20_adc.c pcb20_can.c pcb20_i2c.c pcb20_menu.c pcb20_oled.c pcb20_rtc.c pcb20_spi_e.c pcb20_system.c pcb20_uart.c stm32f4xx_it.c usbd_cdc_interface.c usbd_combo.c usbd_conf.c usbd_desc.c
    ../../Inc/: main.h pca9685.h pcb20_defines.c stm32f4xx_hal_conf.h stm32f4xx_it.h usbd_combo.h
  group Drivers/CMSIS
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_usb.c
  group Middlewares/USB_Device_Library
    ../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
